# Keil uVision project Project.uvprojx, settings and files
target stm32glcd_base (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_blink +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\cmsis;..\main;..\usr_lib;..\ctt;..\sensor;..\free_rtos;..\STM32F10x_StdPeriph;..\STM32F10x_StdPeriph\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StdPeriph
    ../STM32F10x_StdPeriph/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group usr_lib
    ../usr_lib/: queue.c usr_delay.c usr_key.c usr_led.c usr_sys.c usr_usart.c usr_timer.c usr_tsensor.c usr_adc.c usr_rtc.c usr_fram.c usr_spi.c usr_ad9850.c usr_extint.c
  group main
    ../main/: main.c stm32f10x_it.c system_stm32f10x.c
  group console
    ../ctt/: console.c gpio.c menu.c fram.c dds.c
  group sensor
    ../sensor/: adns5020.c
  group freertos
    ../free_rtos/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group cmsis
    ../cmsis/: core_cm3.c startup_stm32f10x_hd.s
software components: CMSIS:CORE 4.3.0
